DESCRIPTION = "backwards-compatible with the standard ‘re’ module, but offers additional functionality"
HOMEPAGE = "https://pypi.org/progect/regex"
SECTION = "devel/python"
LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://setup.py;md5=fbc18117d00431a2edd4db8c632b7298"

SRC_URI[md5sum] = "d31ec392ab75b894404d8db76dacd191"
SRC_URI[sha256sum] = "587b62d48ca359d2d4f02d486f1f0aa9a20fbaf23a9d4198c4bed72ab2f6c849"

inherit pypi setuptools3
