FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0000-Add-higher-baud-rates.patch"
