PACKAGECONFIG_append = " tui"
