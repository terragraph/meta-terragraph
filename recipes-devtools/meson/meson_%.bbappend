FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-backport-support-for-l-libfoo.a.patch"
