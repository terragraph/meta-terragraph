DESCRIPTION = "Diff JSON and JSON-like structures in Python."

HOMEPAGE = "https://pypi.org/project/six/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=792c1f2e813587ebc2e046ff8dff59ae"

SRC_URI[md5sum] = "d48297d9253356b7f71e38268e7e0d10"

inherit pypi setuptools3
