CFLAGS_append_class-native = " -fPIC"
