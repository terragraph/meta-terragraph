# Add the chardetect utility to the cli package.
FILES_${PN}-cli += " \
    ${bindir}/chardetect3 \
"
