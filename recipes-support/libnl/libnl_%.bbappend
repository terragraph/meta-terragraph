FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://fix-route-obj-attr-list.patch \
           "
