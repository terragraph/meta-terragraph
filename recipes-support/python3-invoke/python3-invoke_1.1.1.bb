DESCRIPTION = "A library for managing shells and cli like execution"
HOMEPAGE = "https://pypi.python.org/pypi/invoke"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=be84051d4dcc8a3fd48c513895d00daf"

SRC_URI[md5sum] = "82b537a875d7580311a80f8ceff5d0de"
SRC_URI[sha256sum] = "1c2cf54c9b9af973ad9704d8ba81b225117cab612568cacbfb3fc42958cc20a9"

inherit pypi setuptools3
