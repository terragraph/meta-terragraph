PACKAGECONFIG_append = " zstd"
