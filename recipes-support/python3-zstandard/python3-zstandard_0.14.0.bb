DESCRIPTION = "Python3 bindings for the zstd library"

HOMEPAGE = "https://pypi.org/project/zstandard/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3ae87c50fd64b6f0942823686871e758"

SRC_URI[md5sum] = "1f3b4a5f6a021bc1187822a76626e337"

inherit pypi setuptools3
