BBCLASSEXTEND = "native"

DEPENDS += "gflags"
