RDEPENDS_${PN}_remove = "${PYTHON_PN}-ndg-httpsclient"
