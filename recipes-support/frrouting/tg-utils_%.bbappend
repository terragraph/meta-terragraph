SYSDUMP_LOGS := "${SYSDUMP_LOGS} /var/log/bgpd/* /var/log/zebra/*"
