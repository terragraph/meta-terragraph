DESCRIPTION = "A dictionary that supports java-like attribute access"
HOMEPAGE = "https://pypi.python.org/pypi/bunch"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f0291cd32b2d6a91d9b19970c94d0a46"

SRC_URI[md5sum] = "0a829d64e95ed96defbcae2bf9061bb0"
SRC_URI[sha256sum] = "50c77a0fc0cb372dfe48b5e11937d5f70e743adbf42683f3a6d2857645a76aaa"

inherit pypi setuptools3
