SUMMARY = "Base Utils for Terragraph images"

inherit packagegroup

RDEPENDS_${PN} = "\
    openr-squire-linux \
    security \
    tg-scripts \
    "
