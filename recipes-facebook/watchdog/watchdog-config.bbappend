FILESEXTRAPATHS_prepend := "${THISDIR}/watchdog-config:"

SRC_URI += "file://watchdog.conf"
