SYSDUMP_LOGS := " \
    ${SYSDUMP_LOGS} \
    /etc/hostapd/hostapd_* \
    /etc/wpa_supplicant/wpa_supplicant_* \
    /tmp/hostapd_* \
    /var/log/e2e_controller/* \
    /var/log/e2e_minion/* \
    /var/log/frr_bgp_healthcheck/* \
    /var/log/frr_openr_sync/* \
    /var/log/pop_config/* \
    /var/log/quagga/* \
    /var/log/quagga_sync/* \
    /var/log/tunnel_monitor/* \
    /var/log/wpa_supplicant.log \
    "
