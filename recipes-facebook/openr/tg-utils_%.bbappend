SYSDUMP_SCRIPTS := "${SYSDUMP_SCRIPTS} ${THISDIR}/files/utils/openr_dump"
SYSDUMP_LOGS := "${SYSDUMP_LOGS} /var/log/openr/*"
