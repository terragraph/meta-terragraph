DEPENDS_append_class-target += " wigig-dpdk"

EXTRA_OECMAKE += "-DDPDK_RTE_LIBRTE_WIL6210_PMD=1"
