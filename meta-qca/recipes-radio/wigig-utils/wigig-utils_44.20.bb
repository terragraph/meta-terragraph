require tg-qca6430-DPDK-OEMR2-CSU3-2021-06-29-OEM-ver-10-11-0-92-3pp.inc
require wigig-utils.inc

SRC_URI += "file://0001-Don-t-exit-HandleClosedFilesThread-if-file-deletion-.patch;pnum=2"
