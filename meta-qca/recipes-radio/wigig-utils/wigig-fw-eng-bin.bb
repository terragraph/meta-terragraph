require wigig-fw-release-bin.inc

# Pull in the latest OEM firmware.  Use the fw-str version with the
# debug strings if you have it, otherwise just use the 3pp file
# also used by wigig-utils.
require tg-qca6430-eng-fw-str.inc
