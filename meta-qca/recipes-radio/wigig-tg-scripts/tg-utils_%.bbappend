SYSDUMP_LOGS := "${SYSDUMP_LOGS} /var/log/wil6210/*"
