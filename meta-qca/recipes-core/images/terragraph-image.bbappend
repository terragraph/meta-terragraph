IMAGE_INSTALL += "packagegroup-tg-puma"
