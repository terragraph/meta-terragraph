inherit kernel-extra-headers-base

KERNEL_EXTRA_HEADER_PATH = "${STAGING_DIR_TARGET}${includedir}/linux-extra"
export KERNEL_EXTRA_HEADER_PATH
