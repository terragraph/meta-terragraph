# Turn on various developer related flags in the Terragraph code.

inherit asan
inherit clang-analyze
inherit fbtests
