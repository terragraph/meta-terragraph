SYSDUMP_LOGS := "${SYSDUMP_LOGS} /var/log/vpp_chaperone/*"
