SYSDUMP_LOGS := "${SYSDUMP_LOGS} /var/log/vpp/*"
SYSDUMP_SCRIPTS := "${SYSDUMP_SCRIPTS} ${THISDIR}/files/scripts/vpp_dump"
