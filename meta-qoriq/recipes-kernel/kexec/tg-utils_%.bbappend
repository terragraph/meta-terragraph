SYSDUMP_LOGS := "${SYSDUMP_LOGS} /data/kernel_crashes/*"
