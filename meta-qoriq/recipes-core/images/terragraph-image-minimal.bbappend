terragraph-image.bbappend